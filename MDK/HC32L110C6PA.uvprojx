# Keil uVision project HC32L110C6PA.uvprojx, settings and files
target HC32L110C6PA_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: HC32L110C6PA
  c flags: Optim=1
  c include: ..\common;..\source;..\driver\inc;..\user
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group common
    ./: startup_hc32l110c6pa.s
    ../common/: system_hc32l110c6pa.c
  group source
    ../user/: main.c
  group Driver
    ../driver/src/: gpio.c uart.c ddl.c clk.c bt.c interrupts_hc32l110.c rtc.c lpm.c
  group Application
    ../user/: MyUART.c MyApplication.h Timer0.c 8266.c MyGPIO.c
software components: CMSIS:CORE 4.1.0
